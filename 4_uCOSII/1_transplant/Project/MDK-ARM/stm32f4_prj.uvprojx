# Keil uVision project stm32f4_prj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_prj
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,STM32F407xx
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\User\App;..\..\User\Bsp;..\..\Middlewares\uCOSII\Ports;..\..\Middlewares\uCOSII\Source;..\..\Middlewares\uCOSII\Cfg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMISIS/startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User/App
    ../../User/App/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group User/Bsp
    ../../User/Bsp/: key.c debug_usart1.c bsp.h led.c timer3.c
  group Middlewares/uCOSII/port
    ../../Middlewares/uCOSII/Ports/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group Middlewares/uCOSII/source
    ../../Middlewares/uCOSII/Source/: ucos_ii.c os_dbg_r.c
  group Middlewares/uCOSII/cfg
    ../../Middlewares/uCOSII/Cfg/: app_hooks.c os_cfg.h app_cfg.h
